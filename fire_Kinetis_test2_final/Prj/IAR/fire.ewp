# IAR project fire.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire.srec
  ILINK.IlinkOutputFile: fire.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration DN10 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App\Inc; ..\..\App; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  OBJCOPY.OOCOutputFile: fire.hex
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  group App
    ../../App/Inc/: define.h extern.h include.h MK60_conf.h MK60_it.h PORT_cfg.h
    ../../App/: main.c MK60_conf.c MK60_it.c system.c
  group Board
    ../../Board/Src/: lcd.c Motor.c OLED.c Screen.c SEEKFREE_MT9V032.c VCAN_camera.c VCAN_computer.c VCAN_key.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c VCAN_RTC_count.C VCAN_SCCB.c
    ../../Board/Inc/: Motor.h
  group Chip
    ../../Chip/Src/: misc.c MK60_adc.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/Src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
